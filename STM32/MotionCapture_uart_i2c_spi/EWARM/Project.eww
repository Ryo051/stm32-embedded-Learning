<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MotionCapture_uart_i2c_spi.ewp</path>
  </project>
  <batchBuild />
</workspace>
